# Keil uVision project UsbKeyboardWithMouse(TwoInterfaces).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: UsbKeyboardWithMouse(TwoInterfaces) +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil-C51\C51\INC\Atmel
  group Source Group 1
    ./: STARTUP.A51 Main.c Key.c UART.c PDIUSBD12.c UsbCore.c
