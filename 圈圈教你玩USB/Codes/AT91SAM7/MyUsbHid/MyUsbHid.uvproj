# Keil uVision project MyUsbHid.uvproj, settings and files
target Target 1 ()
  device: AT91SAM7S64 Atmel
  cpu: IRAM(0x200000-0x203FFF) IROM(0x100000-0x10FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: MyUsbHid +hex
  group Source Group 1
    ./: SAM7S.s main.c SystemClock.c UART.c UsbCore.c AT91SAMxUSB.c ADC.c Key.c LCD.C LED.C Timer.c
